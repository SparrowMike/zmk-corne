## boards/shields/corne_dongle/Kconfig.shield
```kconfig
config SHIELD_CORNE_DONGLE_NANO
	def_bool $(shields_list_contains,corne_dongle_nano)
```
